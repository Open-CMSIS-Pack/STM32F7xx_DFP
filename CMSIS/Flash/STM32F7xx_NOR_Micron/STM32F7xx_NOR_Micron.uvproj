# Keil uVision project STM32F7xx_NOR_Micron.uvproj, settings and files
target STM32F7xx_NOR_Micron (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: STM32F7xx_NOR_Micron
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: PC28F128M29EWxx
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
